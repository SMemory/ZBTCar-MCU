# IAR project ZBTCar.ewp, settings and files
configuration ZBTCar (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\lvgl; ..\Middlewares\lvgl\src; ..\Middlewares\lvgl\porting; ..\Middlewares\lvgl\src\lv_core; ..\Middlewares\lvgl\src\lv_draw; ..\Middlewares\lvgl\src\lv_font; ..\Middlewares\lvgl\src\lv_hal; ..\Middlewares\lvgl\src\lv_misc; ..\Middlewares\lvgl\src\lv_objx; ..\Middlewares\lvgl\src\lv_themes; ..\Middlewares; ..\Function
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: ZBTCar.hex
  ILINK.IlinkOutputFile: ZBTCar.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Function
    ../Function/: func_drv.c func_uart.c lcd_gui.c lcd_ili9341.c lcd_lvgl.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LittlevGL
    ../Middlewares/: lv_conf.h
    ../Middlewares/lvgl/: lvgl.h
  group Middlewares/LittlevGL/src
    ../Middlewares/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Middlewares/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Middlewares/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Middlewares/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../Middlewares/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
